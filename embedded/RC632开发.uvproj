# Keil uVision project RC632开发.uvproj, settings and files
target 射频读写卡器 (MCS-51)
  device: SST89E554RC SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(40000000)
  output: ant +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group 主程序
    ./src/: MAIN.C SlRc632.C uart.c delay.c
  group ISO14443A
    ./src/: ISO14443A.C
  group ISO14443B
    ./src/: ISO14443B.C
  group ISO15693
    ./src/: ISO15693.C
